Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: afa75e21-9bef-4957-a981-0082ff65970c, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: PARASASSI.ifc
Time: 2025-10-19T13:39:05+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ITA) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto

# IfcBuildingStorey: Livello:Livello 1, Livello 1
LongName: Livello 1; Elevation: 0 mm
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello 1; ID tipo: 1899; Tipo: Livello 1
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: Livello 1; Piano edificio: yes; Strutturale: no
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Solido; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello 1

# IfcRailing: PARASSASI_R23:PARASSASI_R23, PARASSASI_R23:PARASSASI_R23:13284
In: Livello 1
Type - Material: <Unnamed>, wood, Metal, Mesh
Type - Altro - Categoria: Ringhiere: Supporti; Nome famiglia: PARASSASI_R23
Type - Costruzione - Altezza: 125 mm
Type - Dati identità - Acciaio CAM Strade: Conforme; Altezza_2: 2 mm; applicazione: Fondazione; Descrizione: (colore); EPD: n.a.; GWP totale cradle to gate: n.a.; Interasse: 3.1; Legno CAM Strade: CoC PEFC; lunghezza: n.a.; materiale: Acciaio S355J0WP e Legno lamellare GL24H; Modello: Stone-01; Nome del tipo: PARASSASI_R23; Prezzo di Capitolato: n.a.; Prodotto: Barriera parasassi; Produttore: Margaritelli Road Safety; Unità di Misura: m; URL: https://margaritelli-rs.com/it/altri-prodotti/complementari/; URL (certificati CE. DOP. manuali. schede tecniche. schemi): https://margaritelli-rs.com/it/altri-prodotti/complementari/
Type - Pset_ManufacturerTypeInformation - Manufacturer: Margaritelli Road Safety
Pset_QuantityTakeOff - Reference: PARASSASI_R23
Pset_RailingCommon - Reference: PARASSASI_R23; IsExternal: no
Altro - Famiglia: PARASSASI_R23; Famiglia e tipo: PARASSASI_R23: PARASSASI_R23; ID tipo: 13268; Tipo: PARASSASI_R23
Vincoli - Gioco mano: 0 mm; Host: Livello : Livello 1; Livello: Livello 1; Offset da host: 0 mm; Sposta con gli elementi più vicini: no
Quote - Area: 25.8759 m2; Volume: 0.422959 m3
